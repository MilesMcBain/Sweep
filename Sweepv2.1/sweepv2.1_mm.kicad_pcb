# Repository MilesMcBain/Sweep

## KiCad design Sweepv2.1/sweepv2.1_mm.kicad_pcb

Board: 2 copper layers, 216.9 x 86.9 mm, 48 parts (2 on the bottom side), 43 nets.

Parts:
Bat+1: MountingHole_Pad; 1pin_conn
Bat+r1: MountingHole_Pad; 1pin_conn
BatGND1, BatGND4: MountingHole_Pad; 1pin_conn
J1, J2: AudioJack4dpb; TRRS-PJ-320A
RSW1, RSW2: SW_Push; SW_SPST_B3U-1000P
SW2, SW2_r1, SW3, SW3_r1, SW4, SW4_r1, SW5, SW5_r1, SW6, SW6_r1, SW7_r1, SW8, SW8_r1, SW9, SW9_r1, SW10, SW11, SW11_r1, SW12, SW12_r1, SW13_r1, SW14, SW15, SW15_r1, SW16, SW16_r1, SW17, SW17_r1, SW18, SW18_r1, SW20, SW20_r1, SW21, SW21_r1: SW_Push; SW_PG1350_nonrev_DPB
SW_POWER1: SW_SPDT; SPDT_C128955
SW_POWERR1: SW_SPDT; SPDT_C128955
U1, U2: ProMicro-kbd; ProMicro_v3_min
mouse-bite-2mm-slot, mouse-bite-2mm-slot#2: VAL**; mouse-bite-5mm-slot-with-space-for-track

Connections:
BT+: Bat+1.1, SW_POWER1.2
BT+_r: Bat+r1.1, SW_POWERR1.2
Switch1: SW2.1, U1.10
Switch1_r: SW2_r1.1, U2.10
Switch2: SW3.1, U1.17
Switch2_r: SW3_r1.1, U2.17
Switch3: SW4.1, U1.18
Switch3_r: SW4_r1.1, U2.18
Switch4: SW5.1, U1.19
Switch4_r: SW5_r1.1, U2.19
Switch5: SW6.1, U1.20
Switch5_r: SW6_r1.1, U2.20
Switch6: SW8.1, U1.16
Switch6_r: SW7_r1.1, U2.16
Switch7: SW9.1, U1.15
Switch7_r: SW8_r1.1, U2.15
Switch8: SW10.1, U1.14
Switch8_r: SW9_r1.1, U2.14
Switch9: SW11.1, U1.13
Switch9_r: SW11_r1.1, U2.13
Switch10: SW12.1, U1.1
Switch10_r: SW12_r1.1, U2.1
Switch11: SW14.1, U1.5
Switch11_r: SW13_r1.1, U2.5
Switch12: SW15.1, U1.6
Switch12_r: SW18_r1.1, U2.6
Switch13: SW16.1, U1.7
Switch13_r: SW15_r1.1, U2.7
Switch14: SW17.1, U1.8
Switch14_r: SW16_r1.1, U2.8
Switch15: SW18.1, U1.9
Switch15_r: SW17_r1.1, U2.9
Switch16: SW21.1, U1.11
Switch16_r: SW21_r1.1, U2.11
Switch17: SW20.1, U1.12
Switch17_r: SW20_r1.1, U2.12
Switch18: J2.R1, U1.2
Switch18_r: J1.R1, U2.2
gnd: BatGND1.1, BatGND4.1, J1.S, J1.T, J2.S, J2.T, RSW1.1, RSW2.1, SW2.2, SW2_r1.2, SW3.2, SW3_r1.2, SW4.2, SW4_r1.2, SW5.2, SW5_r1.2, SW6.2, SW6_r1.2, SW7_r1.2, SW8.2, SW8_r1.2, SW9.2, SW9_r1.2, SW10.2, SW11.2, SW11_r1.2, SW12.2, SW12_r1.2, SW13_r1.2, SW14.2, SW15.2, SW15_r1.2, SW16.2, SW16_r1.2, SW17.2, SW17_r1.2, SW18.2, SW18_r1.2, SW20.2, SW20_r1.2, SW21.2, SW21_r1.2, U1.3, U1.4, U1.23, U2.3, U2.4, U2.23
raw: SW_POWER1.3, SW_POWERR1.3, U1.24, U2.24
reset: RSW1.2, U1.22
reset_r: RSW2.2, U2.22
vcc: J1.R2, J2.R2, U1.21, U2.21

## Commit log

2021-12-01 customise column stagger
